# Keil uVision project demo.uvprojx, settings and files
target STM32_Attitude_Control (5060528::V5.06 update 5 (build 528)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: demo +hex
  c flags: Optim=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\libraies\STM32F10x_StdPeriph_Driver\inc;..\libraies\CMSIS\CM3\CoreSupport;..\USER;..\USER\Hardware;..\USER\Algorithm;..\USER\System;..\libraies\CMSIS\CM3\DeviceSupport\ST\STM32F10x
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../USER/: main.c stm32f10x_it.c
  group StdPeriph_Driver
    ../libraies/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../libraies/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../libraies/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Startup
    ../libraies/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group Document
    ../: README.txt
  group Algorithm
    ../USER/Algorithm/: Filter.c PID.c
  group Hardware
    ../USER/Hardware/: adc.c Encoder.c i2c.c MPU6050.c OLED.c Servo.c spi.c w25q64.c
  group System
    ../USER/System/: SysTick.c usart.c
software components: CMSIS:CORE 6.2.0
